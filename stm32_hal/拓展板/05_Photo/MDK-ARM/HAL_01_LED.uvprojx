# Keil uVision project HAL_01_LED.uvprojx, settings and files
target HAL_01_LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: HAL_01_LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Core\Src\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group BSP
    ../Core/Src/BSP/led/: led.c
    ../Core/Src/BSP/key/: key.c
    ../Core/Src/BSP/lcd/: lcd.c
    ../Core/Src/BSP/usart/: uart.c
    ../Core/Src/BSP/iic/: i2c.c
    ../Core/Src/BSP/adc/: adc.c
    ../Core/Src/BSP/tim/: tim.c
    ../Core/Src/BSP/rtc/: rtc.c
    ../Core/Src/BSP/seg/: seg.c
    ../Core/Src/BSP/ds18b20/: ds18b20_hal.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
